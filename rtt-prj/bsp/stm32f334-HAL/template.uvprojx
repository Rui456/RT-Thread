# Keil uVision project template.uvprojx, settings and files
target rt-thread_stm32f3xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F334C6Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: rtthread-stm32f3xx +hex
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\stm32_rom.sct
